v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 130 -1710 130 -1660 {
lab=#net1}
N 130 -1820 130 -1770 {
lab=#net2}
N 130 -1930 130 -1880 {
lab=#net3}
N 130 -2040 130 -1990 {
lab=#net4}
N 130 -2150 130 -2100 {
lab=#net5}
N 130 -2260 130 -2210 {
lab=#net6}
N 130 -2370 130 -2320 {
lab=#net7}
N 130 -2510 130 -2430 {
lab=res_in}
N 130 -2680 130 -2570 {
lab=dum_in}
N 60 -2680 130 -2680 {
lab=dum_in}
N 610 -1670 660 -1670 {
lab=#net8}
N 660 -1780 660 -1670 {
lab=#net8}
N 610 -1780 660 -1780 {
lab=#net8}
N 630 -1890 660 -1890 {
lab=#net9}
N 660 -2000 660 -1890 {
lab=#net9}
N 630 -2000 660 -2000 {
lab=#net9}
N 630 -2110 660 -2110 {
lab=#net10}
N 630 -2220 660 -2220 {
lab=#net10}
N 660 -2220 660 -2110 {
lab=#net10}
N 630 -2330 660 -2330 {
lab=#net11}
N 660 -2440 660 -2330 {
lab=#net11}
N 630 -2440 660 -2440 {
lab=#net11}
N 620 -1500 680 -1500 {
lab=#net12}
N 80 -2470 130 -2470 {
lab=res_in}
N 80 -1550 130 -1550 {
lab=res_out}
N 110 -1630 110 -1470 {
lab=vss}
N 110 -1740 110 -1630 {
lab=vss}
N 110 -1850 110 -1740 {
lab=vss}
N 110 -1960 110 -1850 {
lab=vss}
N 110 -2070 110 -1960 {
lab=vss}
N 110 -2180 110 -2070 {
lab=vss}
N 110 -2290 110 -2180 {
lab=vss}
N 110 -2400 110 -2290 {
lab=vss}
N 40 -1470 110 -1470 {
lab=vss}
N 110 -1470 110 -1390 {
lab=vss}
N 110 -1390 300 -1390 {
lab=vss}
N 300 -2510 300 -1390 {
lab=vss}
N 300 -2510 330 -2510 {
lab=vss}
N 300 -2360 330 -2360 {
lab=vss}
N 300 -2250 330 -2250 {
lab=vss}
N 300 -2140 330 -2140 {
lab=vss}
N 300 -2030 330 -2030 {
lab=vss}
N 300 -1920 330 -1920 {
lab=vss}
N 300 -1810 330 -1810 {
lab=vss}
N 300 -1700 330 -1700 {
lab=vss}
N 300 -1590 330 -1590 {
lab=vss}
N 300 -1420 330 -1420 {
lab=vss}
N 310 -1500 330 -1500 {
lab=vdd}
N 310 -2730 310 -1500 {
lab=vdd}
N 60 -2730 310 -2730 {
lab=vdd}
N 310 -2590 330 -2590 {
lab=vdd}
N 310 -2440 330 -2440 {
lab=vdd}
N 310 -2330 330 -2330 {
lab=vdd}
N 310 -2220 330 -2220 {
lab=vdd}
N 310 -2110 330 -2110 {
lab=vdd}
N 310 -2000 330 -2000 {
lab=vdd}
N 310 -1890 330 -1890 {
lab=vdd}
N 310 -1780 330 -1780 {
lab=vdd}
N 310 -1670 330 -1670 {
lab=vdd}
N 130 -1530 290 -1530 {
lab=res_out}
N 290 -1530 290 -1460 {
lab=res_out}
N 290 -1460 330 -1460 {
lab=res_out}
N 130 -1690 290 -1690 {
lab=#net1}
N 290 -1690 290 -1630 {
lab=#net1}
N 290 -1630 330 -1630 {
lab=#net1}
N 130 -1800 290 -1800 {
lab=#net2}
N 290 -1800 290 -1740 {
lab=#net2}
N 290 -1740 330 -1740 {
lab=#net2}
N 130 -1910 290 -1910 {
lab=#net3}
N 290 -1910 290 -1850 {
lab=#net3}
N 290 -1850 330 -1850 {
lab=#net3}
N 130 -2020 290 -2020 {
lab=#net4}
N 290 -2020 290 -1960 {
lab=#net4}
N 290 -1960 330 -1960 {
lab=#net4}
N 130 -2130 290 -2130 {
lab=#net5}
N 290 -2130 290 -2070 {
lab=#net5}
N 290 -2070 320 -2070 {
lab=#net5}
N 320 -2070 330 -2070 {
lab=#net5}
N 130 -2240 290 -2240 {
lab=#net6}
N 290 -2240 290 -2180 {
lab=#net6}
N 290 -2180 330 -2180 {
lab=#net6}
N 130 -2350 290 -2350 {
lab=#net7}
N 290 -2350 290 -2290 {
lab=#net7}
N 290 -2290 320 -2290 {
lab=#net7}
N 320 -2290 330 -2290 {
lab=#net7}
N 60 -2470 80 -2470 {
lab=res_in}
N 130 -1600 130 -1500 {
lab=res_out}
N 130 -1440 130 -1360 {
lab=dum_out}
N 40 -1360 130 -1360 {
lab=dum_out}
N 130 -2460 290 -2460 {
lab=res_in}
N 290 -2460 290 -2400 {
lab=res_in}
N 290 -2400 330 -2400 {
lab=res_in}
N 300 -2530 300 -2510 {
lab=vss}
N 300 -2530 330 -2530 {
lab=vss}
N 310 -2570 330 -2570 {
lab=vdd}
N 1080 -1780 1140 -1780 {
lab=#net13}
N 1080 -1990 1140 -1990 {
lab=#net13}
N 1140 -1990 1140 -1780 {
lab=#net13}
N 1080 -2200 1150 -2200 {
lab=#net14}
N 1150 -2420 1150 -2200 {
lab=#net14}
N 1090 -2420 1150 -2420 {
lab=#net14}
N 1550 -2340 1630 -2340 {
lab=out}
N 1550 -1930 1630 -1930 {
lab=out}
N 1630 -2340 1630 -1930 {
lab=out}
N 1630 -2340 1720 -2340 {
lab=out}
N 750 -1780 780 -1780 {
lab=vdd}
N 750 -2730 750 -1780 {
lab=vdd}
N 310 -2730 750 -2730 {
lab=vdd}
N 1230 -2730 1230 -2340 {
lab=vdd}
N 1230 -2340 1250 -2340 {
lab=vdd}
N 1230 -2340 1230 -1930 {
lab=vdd}
N 1230 -1930 1250 -1930 {
lab=vdd}
N 750 -1990 780 -1990 {
lab=vdd}
N 750 -2200 780 -2200 {
lab=vdd}
N 750 -2420 790 -2420 {
lab=vdd}
N 750 -2730 1230 -2730 {
lab=vdd}
N 740 -2340 780 -2340 {
lab=vss}
N 740 -2340 740 -1390 {
lab=vss}
N 300 -1390 740 -1390 {
lab=vss}
N 740 -1700 780 -1700 {
lab=vss}
N 740 -1910 780 -1910 {
lab=vss}
N 740 -2120 780 -2120 {
lab=vss}
N 780 -2340 790 -2340 {
lab=vss}
N 1220 -2260 1250 -2260 {
lab=vss}
N 1220 -2260 1220 -1390 {
lab=vss}
N 740 -1390 1220 -1390 {
lab=vss}
N 1220 -1850 1250 -1850 {
lab=vss}
N 660 -1740 780 -1740 {
lab=#net8}
N 660 -1950 780 -1950 {
lab=#net9}
N 660 -2160 780 -2160 {
lab=#net10}
N 660 -2380 790 -2380 {
lab=#net11}
N 1150 -2300 1250 -2300 {
lab=#net14}
N 1140 -1890 1250 -1890 {
lab=#net13}
N 270 -1650 330 -1650 {
lab=b0}
N 270 -1720 330 -1720 {
lab=b0}
N 270 -1870 330 -1870 {
lab=b0}
N 270 -1940 330 -1940 {
lab=b0}
N 270 -2090 330 -2090 {
lab=b0}
N 270 -2160 330 -2160 {
lab=b0}
N 270 -2310 330 -2310 {
lab=b0}
N 270 -2380 330 -2380 {
lab=b0}
N 60 -2790 270 -2790 {
lab=b0}
N 250 -1610 330 -1610 {
lab=b0b}
N 250 -1830 330 -1830 {
lab=b0b}
N 250 -1980 330 -1980 {
lab=b0b}
N 250 -1760 330 -1760 {
lab=b0b}
N 250 -2050 330 -2050 {
lab=b0b}
N 250 -2200 330 -2200 {
lab=b0b}
N 250 -2270 330 -2270 {
lab=b0b}
N 250 -2420 330 -2420 {
lab=b0b}
N 720 -2830 720 -1720 {
lab=b1b}
N 720 -1720 780 -1720 {
lab=b1b}
N 720 -1970 780 -1970 {
lab=b1b}
N 720 -2140 780 -2140 {
lab=b1b}
N 720 -2400 790 -2400 {
lab=b1b}
N 60 -2830 720 -2830 {
lab=b1b}
N 60 -2810 700 -2810 {
lab=b1}
N 700 -2810 700 -1760 {
lab=b1}
N 700 -1760 780 -1760 {
lab=b1}
N 700 -1930 780 -1930 {
lab=b1}
N 700 -2180 780 -2180 {
lab=b1}
N 700 -2360 790 -2360 {
lab=b1}
N 1200 -2870 1200 -1870 {
lab=b2b}
N 1200 -1870 1250 -1870 {
lab=b2b}
N 1200 -2320 1250 -2320 {
lab=b2b}
N 60 -2870 1200 -2870 {
lab=b2b}
N 60 -2850 1180 -2850 {
lab=b2}
N 1180 -2850 1180 -1910 {
lab=b2}
N 1180 -1910 1250 -1910 {
lab=b2}
N 1180 -2280 1250 -2280 {
lab=b2}
N 110 -2540 110 -2400 {
lab=vss}
N 60 -2770 250 -2770 {
lab=b0b}
N 630 -2700 680 -2700 {
lab=#net12}
N 630 -1370 680 -1370 {
lab=#net12}
N 300 -1390 300 -1290 {
lab=vss}
N 300 -1290 330 -1290 {
lab=vss}
N 310 -1500 310 -1370 {
lab=vdd}
N 310 -1370 330 -1370 {
lab=vdd}
N 310 -1370 310 -1350 {
lab=vdd}
N 310 -1350 330 -1350 {
lab=vdd}
N 240 -1330 330 -1330 {
lab=#net12}
N 300 -1310 330 -1310 {
lab=vss}
N 250 -2770 250 -1610 {
lab=b0b}
N 270 -2790 270 -1650 {
lab=b0}
N 310 -2700 330 -2700 {
lab=vdd}
N 300 -2640 300 -2530 {
lab=vss}
N 300 -2640 330 -2640 {
lab=vss}
N 300 -2620 330 -2620 {
lab=vss}
N 310 -2680 330 -2680 {
lab=vdd}
N 280 -2550 330 -2550 {
lab=dum_in}
N 280 -2620 280 -2550 {
lab=dum_in}
N 130 -2620 280 -2620 {
lab=dum_in}
N 220 -2660 330 -2660 {
lab=#net12}
N 240 -1330 240 -1250 {
lab=#net12}
N 240 -1250 680 -1250 {
lab=#net12}
N 680 -1370 680 -1250 {
lab=#net12}
N 220 -2750 680 -2750 {
lab=#net12}
N 220 -2750 220 -2660 {
lab=#net12}
N 310 -1480 330 -1480 {
lab=vdd}
N 300 -1440 330 -1440 {
lab=vss}
N 630 -2590 680 -2590 {
lab=#net12}
N 680 -2750 680 -2590 {
lab=#net12}
N 680 -1500 680 -1370 {
lab=#net12}
C {passtrans.sym} 480 -1630 0 0 {name=x1}
C {sky130_fd_pr/res_high_po_0p35.sym} 130 -1630 0 0 {name=R1
W=0.35
L=3
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {passtrans.sym} 480 -1740 0 0 {name=x2}
C {passtrans.sym} 480 -1850 0 0 {name=x3}
C {passtrans.sym} 480 -1960 0 0 {name=x4}
C {passtrans.sym} 480 -2070 0 0 {name=x5}
C {passtrans.sym} 480 -2180 0 0 {name=x6}
C {passtrans.sym} 480 -2290 0 0 {name=x7}
C {passtrans.sym} 480 -2400 0 0 {name=x8}
C {passtrans.sym} 480 -2550 0 0 {name=x9}
C {passtrans.sym} 480 -1460 0 0 {name=x10}
C {sky130_fd_pr/res_high_po_0p35.sym} 130 -1740 0 0 {name=R2
W=0.35
L=3
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 130 -1850 0 0 {name=R3
W=0.35
L=3
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 130 -1960 0 0 {name=R4
W=0.35
L=3
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 130 -2070 0 0 {name=R5
W=0.35
L=3
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 130 -2180 0 0 {name=R6
W=0.35
L=3
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 130 -2290 0 0 {name=R7
W=0.35
L=3
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 130 -2400 0 0 {name=R8
W=0.35
L=3
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 130 -2400 0 0 {name=R9
W=0.35
L=3
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 130 -2540 0 0 {name=R10
W=0.35
L=3
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 130 -1470 0 0 {name=R12
W=0.35
L=3
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {devices/ipin.sym} 60 -2470 0 0 {name=p1 lab=res_in}
C {devices/ipin.sym} 40 -1470 0 0 {name=p3 lab=vss}
C {devices/ipin.sym} 60 -2730 0 0 {name=p4 lab=vdd}
C {passtrans.sym} 940 -2380 0 0 {name=x11}
C {passtrans.sym} 930 -2160 0 0 {name=x12}
C {passtrans.sym} 930 -1950 0 0 {name=x13}
C {passtrans.sym} 930 -1740 0 0 {name=x14}
C {passtrans.sym} 1400 -2300 0 0 {name=x15}
C {passtrans.sym} 1400 -1890 0 0 {name=x16}
C {devices/opin.sym} 1720 -2340 0 0 {name=p5 lab=out}
C {devices/ipin.sym} 60 -2790 0 0 {name=p6 lab=b0}
C {devices/ipin.sym} 60 -2770 0 0 {name=p7 lab=b0b}
C {devices/ipin.sym} 60 -2810 0 0 {name=p8 lab=b1}
C {devices/ipin.sym} 60 -2830 0 0 {name=p9 lab=b1b}
C {devices/ipin.sym} 60 -2850 0 0 {name=p10 lab=b2}
C {devices/ipin.sym} 60 -2870 0 0 {name=p11 lab=b2b}
C {devices/ipin.sym} 60 -2680 0 0 {name=p12 lab=dum_in}
C {devices/opin.sym} 80 -1550 2 0 {name=p2 lab=res_out}
C {devices/opin.sym} 40 -1360 2 0 {name=p13 lab=dum_out}
C {passtrans.sym} 480 -2660 0 0 {name=x17}
C {passtrans.sym} 480 -1330 0 0 {name=x18}
