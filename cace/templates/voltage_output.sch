** sch_path: cace/templates/voltage_output.sch
* Open sourced under Apache 2.0 license
**.subckt voltage_output
VVDAC7 b7 VSUB DC CACE[CACE{b[7]} * CACE{Vdvdd}]
VVDAC1 b1 VSUB DC CACE[CACE{b[1]} * CACE{Vdvdd}]
VVDAC2 b2 VSUB DC CACE[CACE{b[2]} * CACE{Vdvdd}]
VVDAC3 b3 VSUB DC CACE[CACE{b[3]} * CACE{Vdvdd}]
VVDAC4 b4 VSUB DC CACE[CACE{b[4]} * CACE{Vdvdd}]
VVDAC5 b5 VSUB DC CACE[CACE{b[5]} * CACE{Vdvdd}]
VVDAC6 b6 VSUB DC CACE[CACE{b[6]} * CACE{Vdvdd}]
VVDAC0 b0 VSUB DC CACE[CACE{b[0]} * CACE{Vdvdd}]
VVlow Vlow VSUB DC CACE{Vlow}
VVhigh Vhigh VSUB DC CACE{Vhigh}
Vena ena VSUB DC CACE[CACE{ena} * CACE{Vdvdd}]
Vvss vss VSUB DC CACE{Vvss}
Rout out VSUB CACE{Rout} m=1
Cout out VSUB CACE{Cout} m=1
Vdvss dvss VSUB DC CACE{Vdvss}
Vvdd vdd VSUB DC CACE{Vvdd}
Vdvdd dvdd VSUB DC CACE{Vdvdd}
RSUB VSUB GND 0.01 m=1
XDUT dvdd vss dvss vdd b0 Vhigh b1 b2 b3 out b4 b5 ena b6 b7 Vlow ${DUT_name}
**** begin user architecture code

.control
op
set wr_singlescale
wrdata CACE{simpath}/CACE{filename}_CACE{N}.data V(out)
quit
.endc



* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Simple output voltage measurement for a DAC (DC operating point)

.include CACE{DUT_path}
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_hvl/spice/sky130_fd_sc_hvl.spice

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends
.GLOBAL GND
.end
