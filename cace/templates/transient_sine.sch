** sch_path: cace/templates/transient_sine.sch
* Open sourced under Apache 2.0 license
**.subckt transient_sine
VVlow Vlow VSUB DC CACE{Vlow}
VVhigh Vhigh VSUB DC CACE{Vhigh}
Vena ena VSUB DC CACE[CACE{ena} * CACE{Vvdd}]
Vvss vss VSUB DC CACE{Vvss}
Rout out VSUB CACE{Rout} m=1
Cout out VSUB CACE{Cout} m=1
Vdvss dvss VSUB DC CACE{Vdvss}
Vvdd vdd VSUB DC CACE{Vvdd}
Vdvdd dvdd VSUB DC CACE{Vdvdd}
RSUB VSUB GND 0.01 m=1
XDUT dvdd vss dvss vdd b0 Vhigh b1 b2 b3 out b4 b5 ena b6 b7 Vlow ${DUT_name}
A1 [ Db7 ] [ b7 ] dtoa
A2 [ Db6 ] [ b6 ] dtoa
A4 [ Db5 ] [ b5 ] dtoa
A5 [ Db4 ] [ b4 ] dtoa
A7 [ Db3 ] [ b3 ] dtoa
A9 [ Db2 ] [ b2 ] dtoa
A10 [ Db1 ] [ b1 ] dtoa
A11 [ Db0 ] [ b0 ] dtoa
ASINE [ Db7 Db6 Db5 Db4 Db3 Db2 Db1 Db0 ] sinegen
**** begin user architecture code


.control
.option KLU
.options method=GEAR RELTOL=0.001 ABSTOL=1.0e-9
tran 5.0e-6 CACE[CACE{frequency} * 5.0e-6] uic
set wr_singlescale
wrdata CACE{simpath}/CACE{filename}_CACE{N}.data V(out)
quit
.endc



* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Output voltage transient with an input representing a sine wave

.include CACE{DUT_path}
.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_hvl/spice/sky130_fd_sc_hvl.spice

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1




.model sinegen d_source(input_file="CACE{templates}/data/sineCACE{frequency}x4.dat")
.model dtoa dac_bridge(out_high=CACE{Vdvdd} out_low=CACE{Vdvss} t_rise=5.0e-9 t_fall=5.0e-9)


**** end user architecture code
**.ends
.GLOBAL GND
.end
